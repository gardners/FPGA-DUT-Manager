# Repository gardners/FPGA-DUT-Manager

File README.md:

# FPGA-DUT-Manager

Networked supervisors for a remote hardware test farm of **MEGA65** (and later
HewnWeb) boards. Each supervisor is a pre-V4 Numato **Mimas A7** (Artix-7
XC7A50T) that sits between a Linux host on the lab network and two
devices under test (DUTs), and gives the host everything a developer at the
bench would have: JTAG, serial console, keyboard, video, status and power.

The aim is remote, independent control of real hardware for development,
interactive use and automated regression testing, with as little FPGA
logic, extra hardware and cabling as possible. Policy lives in host
software; the FPGA stays a lean UDP frame processor (no soft CPU, no DDR3,
no retransmission logic).

## What it is meant to do

Per DUT, over gigabit Ethernet with its own MAC/IP (DHCP):

* **JTAG**: program and debug the DUT from Vivado or `m65` via a Xilinx
  Virtual Cable (XVC) endpoint, proxied by `dutctl` onto a JTAG-over-UDP
  engine in the FPGA.
* **UART**: the DUT's serial console as UDP streams, with history snapshots
  so nothing is lost when the host reconnects.
* **Keyboard**: the supervisor presents a MEGA65 MK-I keyboard to each DUT;
  the host sets the full key matrix (including holding keys through a cold
  power-on). A real MK-I or MK-II keyboard on the master supervisor can take
  over the selected DUT.
* **Video**: raw RGB888 capture of the DUT's HDMI output (27 MHz modes) sent
  as line packets, reassembled on the host; audio later.
* **Status and power**: heartbeats with complete state snapshots (target
  power sensing, keyboard ownership, UART/JTAG counters, LEDs); per-DUT 12 V
  power through an Arduino-driven relay board.
* **Local console**: an HDMI monitor on the supervisor shows an 80x25 text
  screen pushed by the host, or the selected DUT's video; front-panel
  buttons, seven-segment display and LEDs show identity and state.
* **Scaling**: two supervisors / four DUTs now, up to four / eight, linked
  by simple ribbon cables for shared monitor, keyboard and selection; every
  supervisor also talks to the host directly, so a chain fault never takes
  away remote JTAG or UART.

The full requirements are in [`docs/design-brief-v0.5.md`](docs/design-brief-v0.5.md);
decisions are in [`docs/adrs/`](docs/adrs/0000-index.md), open work in
[`docs/issues/`](docs/issues/).

## Progress (2026-11-25)

**Working on hardware** (Vivado bitstreams; known-good images in `bits/`,
`scripts/hwtest.sh` smoke test 63/0):

* Gigabit Ethernet with a self-calibrating RGMII RX phase, ARP, ICMP,
  per-DUT DHCP; DUT IDs `0x0n` / `0x1m` from the DIP switches; device DNA.
* Heartbeats with link, video and DDR3 blocks; every management key
  (accepts valid, rejects invalid values with the right status).
* HDMI console at 720x480p60 with three screens (editable / no video /
  select), written over UDP (`dutctl text --screen`). HDMI OUT sends HDMI
  with AVI and SPD InfoFrames ("MEGA65 / MEGA KVM Mnn").
* **HDMI IN**: 27 MHz input (Digilent dvi2rgb, made HDMI-aware so guard
  bands and data islands such as audio never reach the picture), our own
  EDID, live passthrough to HDMI OUT, and raster capture: `dutctl video`
  reassembles complete, pixel-exact frames (verified on an HDMI loopback,
  jumbo frames). `dutctl -S` saves a PNG screenshot (issue 0042), checked
  with a real source (a HewnWeb board) on HDMI IN.
* **DDR3** (256 MiB, Xilinx MIG): calibrates and passes its start-up
  self-test. It is used only as a thumbnail store; nothing else depends on
  it.
* **Live thumbnails**: every video source keeps a 320x200 (or 160x100)
  copy in DDR3. Boards exchange them as raw Ethernet frames on request
  (RAW888/RLE24), and the KVM select screen shows them as a 2x2 or 4x3
  mosaic with the selection digit in each corner. A machine with no
  video shows colour bars, an empty slot a frown.
* Physical MK-I keyboard: KVM hotkey (both SHIFTs 1 s + MEGA, or a quick
  LSHIFT/MEGA train, then 1-9, 0) and power-LED status colours.
* Seven-segment status; SPI flash programming (`make flash`).
* **Relay controller** (Arduino Uno, `make relay-flash`): `dutctl relay
  /dev/ttyACM0 POWER 0 1 ON`, `STATUS`, `CYCLE`, `ALL OFF`; relays switch
  on the bench (ADR 0009).

**Implemented, waiting for hardware to test:** JTAG/XVC and UART to a
powered MEGA65, MK-I keyboard emulation towards DUTs, MK-II keyboard host,
passthrough and EDID with a real HDMI source, the thumbnail relay between
two boards, the monitor showing the SPD name.

**Not started:** supervisor chain link (0011), audio, status screen (0017),
reading the monitor's EDID (0037 part 2), GenLock (0039, future), DUT
adapter board (0008), 100 Mb/s Ethernet (0018, low priority).

## Quick start

```
make deps                 # list/install Debian/Ubuntu packages
make test                 # HDL (nvc), dutctl and relay firmware unit tests
make bitstream            # Vivado build -> build/vivado/supervisor.bit
make jtagload             # load it (or: make jtagload-good for bits/known-good.bit)
make dutctl
sw/dutctl/build/dutctl listen -t 5
sw/dutctl/build/dutctl text <ip> "Hello"
sw/dutctl/build/dutctl -S 2              # screenshot of machine 1 (console digit 2)
make relay-flash PORT=/dev/ttyACM0   # relay controller (arduino-cli)
```

### `dutctl` commands

Run `dutctl` without arguments for the list, or a command without arguments
for its options.

| Command | What |
|---|---|
| `listen [-t S] [--kv]` | decode heartbeats |
| `set IP NAME VALUE`, `mgmt IP KEY [HEX]` | management keys (named / raw) |
| `kbd IP [KEY ...]` | hold MEGA65 keys on a DUT |
| `uart IP` | interactive UART bridge |
| `jtag-idcode IP [DUT]\|NAME`, `xvc IP [DUT]\|NAME` | JTAG over UDP, XVC server for Vivado / openFPGALoader; a configured USB-JTAG DUT prints (or `--exec`s) the openFPGALoader command. Shifts are split into requests that fit one unfragmented packet: global `--mtu N` / `$DUTCTL_MTU` (default 1500 = 5792 bits per request; >= 2028 = 7904, the supervisor maximum; issue 0059) |
| `jtag-speed IP [DUT]\|NAME [--kbd] [--save]` | maximum safe octopus TCK (issue 0054) |
| `duts`, `jtag-discover` | per-DUT configuration, USB JTAG adaptor discovery (issue 0053) |
| `relay TTY COMMAND...` | Arduino relay controller (DUT power) |
| `text IP ...` | write the HDMI console text screens |
| `video IP [--enable]` | raw raster capture to PPM frames |
| `thumbs IFACE` | thumbnail relay pictures (raw Ethernet) |
| `screenshot [TARGET] [-o FILE]` (alias `-S`) | one complete frame as PNG/PPM |

**Screenshots** (issue 0042):
`dutctl screenshot [TARGET] [-o FILE.png|.ppm] [--screen auto|editable|novideo|select] [--timeout S]`,
or `dutctl -S ...` as in m65. TARGET is an endpoint IP or a console digit
(1-9, 0 = machine 0-9, as on the select screen); without one, the only
machine that can be captured right now is used (if several can, they are
listed). Only a board's video target DUT can be captured; the video target
is not changed. The command points that DUT's telemetry at this host
(unicast, found from the route to the board), enables capture, waits for
one complete frame (10 s default), then restores capture enable to its
previous state, the telemetry destination to broadcast (the default; the
protocol cannot read the old value) and, if `--screen` forced one, the auto
console screen, also on errors and Ctrl-C. The default file is
`mega65-screenshot-NNNNNN.png`, the lowest free number in the current
directory (never overwritten). PNGs are uncompressed (stored deflate), about
1 MB at 720x480.

**Per-DUT JTAG setup** (issue 0053): `~/.config/dutctl/duts.conf` (or
`$DUTCTL_CONF`, or the global `--conf FILE`) has one `[name]` section per
DUT; `dutctl duts --help` lists the keys:

```ini
[m65-r6]
ip = 192.168.1.50        # supervisor endpoint (octopus JTAG)
dut = 0                  # endpoint index (optional)
jtag = octopus           # or usb
tck_half = 12            # from dutctl jtag-speed --save
kbd_tck_half = 20        # keyboard CPLD, jtag-speed --kbd --save
relay = /dev/ttyACM0 3   # power path (relay controller tty, channel)

[nexys]
jtag = usb
usb_vid = 0403
usb_pid = 6010
usb_serial = 251633000123
ftdi_channel = 0
tty = /dev/ttyUSB5       # the adaptor's UART to the DUT (TE0790)
```

The JTAG commands take a DUT name instead of `IP [DUT]`. For `jtag = octopus`
they use the configured `tck_half` (`xvc`: as the fastest TCK that XVC
`settck` may select); for `jtag = usb` they print the openFPGALoader line
(`--detect` / `--xvc --port N`, chosen by `--ftdi-serial`) plus m65's
`-f SERIAL -l TTY`, or run it with `--exec`. `dutctl duts` lists the DUTs.
The writer edits the file in place, so comments survive.

`dutctl jtag-discover` lists USB JTAG adaptors from sysfs (FTDI
0403:6010/6011/6014/6001, TE0790, Digilent; the Mimas boards 2a19:1009 are
excluded) with their serials and ttys. `--scan` reads each chain with
openFPGALoader `--detect` (FTDI channel 0 by default; libftdi detaches that
channel's ttyUSB; FT232R only with `--all`; adaptors carrying a configured
relay tty are never touched). `--power-cycle --yes` switches each DUT with a
`relay =` power path off, waits (`--wait S`, default 3), rescans, sees whose
chain disappeared, switches the DUT back on, proposes the mapping and
writes it after confirmation (or with `--write`). Without openFPGALoader
there is no chain scan: map by hand or unplug adaptors one at a time.
Adaptors without a USB serial are recorded by port (`usb_path`) and
addressed by bus/device number; replugging can renumber them.

**JTAG speed probe** (issue 0054): `dutctl jtag-speed IP|NAME [--kbd]
[--reps N] [--save]` sweeps the TCK half period from 50 (1.25 MHz) down to
2 (31.25 MHz). Each of the N probes per step (default 200) is one shift:
Test-Logic-Reset and the IDCODE window (compared with the slow reading),
then all IRs to BYPASS and a 2048-bit random, 512 all-0 and 512 all-1 DR
pattern checked after the chain's length. Only IDCODE and BYPASS are used,
so it is safe on a running DUT. The fastest step reached without a failure
is f_max; the recommendation is f_max / 2 (the next swept step at least
twice as slow), which `--save` writes as `tck_half` (`kbd_tck_half` with
`--kbd`). `-v` shows the wrong bits; `--tolerate N` lets a step pass with N
failing probes (for a link with a speed-independent error floor);
`--from` / `--to` limit the sweep.

Hardware notes: power the Mimas from its DC jack (USB power alone is not
enough for the full design); install the udev rule with
`scripts/setup-mimas-udev-rule.sh` (stable `/dev/mimas-<serial>`, and keeps
ModemManager off the JTAG channel); follow the warnings in
`docs/cabling/dut-cable.md` (JTAG and keyboard strips run in opposite
directions next to the 3.3 V rows 9/15/21); never run a full-width cable on the
headers (rows 1-2 carry raw VIN, P13 rows 34-39 are FPGA configuration
pins). An open-source flow (`FLOW=openxc7`: GHDL/yosys/nextpnr-xilinx) is
kept available but Vivado is the default.

## Repository layout

| Path | What |
|---|---|
| `hdl/src/` | VHDL-2008 supervisor (vendor-neutral except `platform/xc7/`) |
| `hdl/tb/`, `tests/scenarios/` | nvc testbenches and Python scenario checks |
| `boards/mimas_a7/` | pin and timing constraints |
| `sw/dutctl/` | Linux CLI in C: protocol codec, UART merge, XVC proxy, relay client |
| `firmware/relay-controller/` | Arduino Uno sketch for the 8-channel relay board (`make relay-fw`, `make relay-flash`) |
| `tests/netproto.py` | reference encoder/decoder for the wire protocol |
| `vivado/`, `scripts/` | Vivado build script, toolchain and board helper scripts |
| `docs/` | design brief, ADRs, issues |
| `bits/` | index of hardware-verified bitstreams |

## Licence

LGPL-2.1-or-later (see file headers). Imported code under `third_party/`
keeps its own licence and provenance.

## KiCad design hardware/mega-kvm-power/mega-kvm-power-main/mega-kvm-power-main.kicad_pcb

Schematic: mega-kvm-power-main.kicad_sch, MEGA-KVM power board - main (eFuse outputs, fans)

Parts:
C1, C2: 470u 25V; CP_Elec_10x10; LCSC TBD (470uF 25V 10x10 SMD)
C3, C504, C505, C600, C601: 10u; C_1206_3216Metric; Voltage 25V; LCSC TBD (X7R 25V)
C4, C507, C514, C515, C516: 1u; C_0603_1608Metric; Voltage 50V; LCSC TBD (X7R 50V)
C5: 1u; C_0603_1608Metric; Voltage 16V; LCSC TBD (X7R 16V)
C6, C7, C400, C401, C402, C403, C404, C405, C506, C602, C723, C724, C732: 100n; C_0603_1608Metric; Voltage 25V; LCSC C14663
C100, C110, C120, C130, C140, C150, C160, C170, C180, C610, C620, C630, C710, C730: 2n2; C_0603_1608Metric; Voltage 50V; LCSC TBD (X7R 50V)
C101, C111, C121, C131, C141, C151, C161, C171, C181, C611, C621, C631, C711, C731: 4n7; C_0603_1608Metric; Voltage 50V; LCSC TBD (X7R 50V)
C102, C103, C112, C113, C122, C123, C132, C133, C142, C143, C152, C153, C162, C163, C172, C173, C182, C183, C501, C502, C503, C612, C613, C622, C623, C632, C633, C712, C713, C733, C734: 1u; C_1206_3216Metric; Voltage 50V; LCSC TBD (X7R 50V)
C511, C512, C513: 22n; C_0603_1608Metric; Voltage 50V; LCSC TBD (X7R 50V)
C517: 10n; C_0603_1608Metric; Voltage 50V; LCSC TBD (X7R 50V)
C720, C721, C722: 10u; C_1206_3216Metric; Voltage 50V; MPN Samsung CL31A106KBHNNNE 10 uF 50 V X5R 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; LCSC C13585
C725, C726, C727: 22u; C_1206_3216Metric; Voltage 25V; MPN Samsung CL31A226KAHNNNE 22 uF 25 V X5R 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; LCSC C12891
D1, D101, D111, D121, D131, D141, D151, D161, D171, D181, D507, D508, D509, D601, D611, D621, D631, D741: green; LED_0603_1608Metric; LCSC TBD (0603 green, JLC basic)
D100, D110, D120, D130, D140, D150, D160, D170, D180, D610, D620, D630, D740: SS34; D_SMA; MPN SS34 40 V 3 A SMA; LCSC C8678
D501, D502, D503: SMCJ15A; D_SMC; MPN MDD SMCJ15A 1500 W, Vrwm 15 V, Vc 24.4 V; LCSC C2834490
D504, D505, D506: B5819W; D_SOD-123; MPN B5819W 40 V 1 A SOD-123; LCSC C8598
D510, D511, D512: BAT54WS; D_SOD-323; MPN Diodes BAT54WS-7-F 30 V 0.2 A Schottky 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; LCSC C124205
D600: SMBJ5.0A; D_SMB; MPN SMBJ5.0A 600 W, Vrwm 5.0 V, Vbr 6.4 V m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; LCSC C2758500
D730: 1N4148WS; D_SOD-323; MPN 1N4148WS 100 V 150 mA SOD-323 (JLC basi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; LCSC C2128
F1: 25A ATO; FuseHolder_Blade_ATO_Littelfuse_FLR_178.6165; MPN Littelfuse 178.6165.0002 ATO PCB holder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; LCSC TBD
F2: 15A ATO; FuseHolder_Blade_ATO_Littelfuse_FLR_178.6165; MPN Littelfuse 178.6165.0002 ATO PCB holder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; LCSC TBD
F3, F4: 10A ATO; FuseHolder_Blade_ATO_Littelfuse_FLR_178.6165; MPN Littelfuse 178.6165.0002 ATO PCB holder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; LCSC TBD
H1, H2, H3, H4, H5, H6, H7, H8: M3; MountingHole_3.2mm_M3
J3: CTRL 1x11 key2; PinHeader_1x11_P2.54mm_Vertical; LCSC TBD (2.54 mm 1x11 header)
J4: STATUS 1x10; PinHeader_1x10_P2.54mm_Vertical; LCSC TBD (2.54 mm 1x10 header)
J5: I2C 1x5; PinHeader_1x05_P2.54mm_Vertical; LCSC TBD
J10: DUT0 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J11: DUT1 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J12: DUT2 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J13: DUT3 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J14: DUT4 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J15: DUT5 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J16: DUT6 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J17: DUT7 12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 2-pole 5.08 mm PCB screw terminal, MKDS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; LCSC TBD: JLC-stocked KF128/DG128-5.08-2P cl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
J20: MIMAS0 12V; Molex_Mini-Fit_Jr_5566-02A_2x01_P4.20mm_Vertical; MPN Molex 39-28-1023 (5566-02A) Mini-Fit Jr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; LCSC TBD
J21: MIMAS1 12V; Molex_Mini-Fit_Jr_5566-02A_2x01_P4.20mm_Vertical; MPN Molex 39-28-1023 (5566-02A) Mini-Fit Jr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; LCSC TBD
J22: GS105 12V; BarrelJack_CUI_PJ-102AH_Horizontal; MPN CUI PJ-102AH 2.1 mm, 2.5 A; LCSC TBD
J30: FAN0; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J31: FAN1; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J32: FAN2; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J33: FAN3; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J34: FAN4; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J35: FAN5; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J36: FAN6; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J37: FAN7; FanPinHeader_1x04_P2.54mm_Vertical; MPN Molex 47053-1000 4-pin PWM fan header; LCSC C240840
J50: BANANA +12V (red); Banana_Jack_1Pin; MPN 4 mm PCB-mount banana socket, red, 24 A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; LCSC C7437321
J51: BANANA GND (black); Banana_Jack_1Pin; MPN 4 mm PCB-mount banana socket, black, 24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; LCSC C7437322
J52: PCIe 8-pin; Molex_Mini-Fit_Jr_5566-08A_2x04_P4.20mm_Vertical; MPN Molex Mini-Fit Jr 8-pin vertical header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; LCSC TBD (JLC-stocked Mini-Fit 2x4 vertical)
J53: Molex 4-pin; Molex_8981_PeripheralPower_1x04_P5.08mm_Vertical; MPN Molex 8981 4-pin male PCB header, verti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; LCSC TBD
J54: MASTER SW; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical; MPN JST B3B-XH-A; LCSC C144395 (verify)
J61: DUT5 5V ONLY; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; MPN JST B2P-VH(LF)(SN) 2-pin 3.96 mm vertic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; LCSC C160315
J62: DUT6 5V ONLY; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; MPN JST B2P-VH(LF)(SN) 2-pin 3.96 mm vertic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; LCSC C160315
J63: DUT7 5V ONLY; JST_VH_B2P-VH_1x02_P3.96mm_Vertical; MPN JST B2P-VH(LF)(SN) 2-pin 3.96 mm vertic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; LCSC C160315
J70: DUT 6V ONLY (K325T); Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal; MPN Molex 43045-0400 Micro-Fit 3.0 2x2 righ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; LCSC C122413
JP1: 3V3 to I2C hdr; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: SW bypass; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP5: CH5 12V|5V; PinHeader_1x03_P2.54mm_Vertical; MPN 2.54 mm 1x3 pin header + 2.54 mm shunt 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; LCSC C2932698 (1x3 2.54 mm header); shunt C1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
JP6: CH6 12V|5V; PinHeader_1x03_P2.54mm_Vertical; MPN 2.54 mm 1x3 pin header + 2.54 mm shunt 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; LCSC C2932698 (1x3 2.54 mm header); shunt C1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
JP7: CH7 12V|5V; PinHeader_1x03_P2.54mm_Vertical; MPN 2.54 mm 1x3 pin header + 2.54 mm shunt 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; LCSC C2932698 (1x3 2.54 mm header); shunt C1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
L70: 4.7u; L_Changjiang_FXL1040; MPN Changjiang FXL1040-4R7-M 4.7 uH, 20 mOh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; LCSC C167230
Q30, Q31, Q32, Q33, Q34, Q35, Q36, Q37, Q509, Q510, Q511: 2N7002; SOT-23; LCSC C8545
Q501, Q502, Q503, Q504, Q505, Q506, Q507, Q508: BSC030P03NS3G; Infineon_PG-TDSON-8_6.15x5.15mm; MPN Infineon BSC030P03NS3G -30 V 3 mOhm; LCSC C152375
Q512, Q513: BSC030P03NS3G; Infineon_PG-TDSON-8_6.15x5.15mm; MPN Infineon BSC030P03NS3G -30 V 3 mOhm; LCSC C152375; not fitted
R1, R104, R114, R124, R134, R144, R154, R164, R174, R184, R302, R312, R322, R332, R342, R352, R362, R372, R401, R402, R403, R404, R405, R406, R407, R408: 4k7; R_0603_1608Metric; Tolerance 1%; LCSC C23162
R2: 113k; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R3, R4, R5, R6, R7, R12, R103, R113, R123, R133, R143, R153, R163, R173, R183, R300, R303, R310, R313, R320, R323, R330, R333, R340, R343, R350, R353, R360, R363, R370, R373, R400, R410, R411, R412, R413, R601, R702: 10k; R_0603_1608Metric; Tolerance 1%; LCSC C25804
R8, R9: 4k7; R_0603_1608Metric; Tolerance 1%; LCSC C23162; not fitted
R10: 10k; R_0603_1608Metric; Tolerance 1%; LCSC C25804; not fitted
R100, R110, R120, R130, R140, R150, R160, R170, R304, R314, R324, R334, R344, R354, R364, R374, R513, R523, R533, R540, R541, R542, R603, R614, R624, R634, R700, R740: 1k; R_0603_1608Metric; Tolerance 1%; LCSC C21190
R101, R111, R121, R131, R141, R151, R161, R171, R602, R611, R621, R631, R701, R741, R742: 20k; R_0603_1608Metric; Tolerance 1%; LCSC C4184
R102, R112, R122, R132, R142, R152, R162, R172, R182, R710: 665; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R180, R301, R311, R321, R331, R341, R351, R361, R371, R503, R505, R507, R508, R509, R512, R522, R532, R605, R720, R732, R734: 100k; R_0603_1608Metric; Tolerance 1%; LCSC C25803
R181: 14k7; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R501: 0R; R_0603_1608Metric; Tolerance 1%; LCSC C21189
R502: 47R; R_1206_3216Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R504, R506, R721: 33k; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R510, R520, R530: 1M27; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R511, R521, R531: 33k2; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R543: 100R; R_0603_1608Metric; Tolerance 1%; LCSC C22775
R604: 392k; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R612, R622, R632: 1k1; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R722: 27k; R_0603_1608Metric; Tolerance 0.1%; LCSC TBD (0603 0.1 % thin film 27k, e.g. Yag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
R723: 3k92; R_0603_1608Metric; Tolerance 0.1%; LCSC TBD (0603 0.1 % thin film 3k92, e.g. Ya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
R730: 715; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R731: 475k; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
R733: 348k; R_0603_1608Metric; Tolerance 1%; LCSC TBD (1%, JLC basic if stocked)
U1, U2, U3, U4, U5, U6, U7, U8, U9, U61, U62, U63, U71, U72: TPS259470ARPWR; Texas_RPW0010A_VQFN-HR-10_2x2mm_P0.45mm; MPN TI TPS259470ARPWR; LCSC C3662799
U10: L78L33ACUTR; SOT-89-3; MPN ST L78L33ACUTR; LCSC TBD (78L33 SOT-89, 30 V in)
U11: TCA9535PWR; TSSOP-24_4.4x7.8mm_P0.65mm; LCSC C130204
U12: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TI TCA9548APWR 8-ch I2C switch, TSSOP-24; LCSC C130026
U13: TMP75AIDR; SOIC-8_3.9x4.9mm_P1.27mm; MPN TI TMP75AIDR (LM75 pinout, 0x48-0x4F), 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; LCSC C30389
U14, U15, U16, U17: EMC2302-1-AIZL-TR; MSOP-10_3x3mm_P0.5mm_Pad0.28; MPN Microchip EMC2302-1-AIZL-TR, 2-ch 26 kH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; LCSC C626969
U30, U31, U32, U33, U34, U35, U36, U37: BSP452; SOT-223; MPN Infineon BSP452 smart high-side switch,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; LCSC C58074
U50: LTC4417CGN; SSOP-24_3.9x8.7mm_P0.635mm; MPN ADI LTC4417CGN#PBF; LCSC C688500 (low stock: order via JLC globa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
U73: TPS565201DDCR; TSOT-23-6; MPN TI TPS565201DDCR 4.5-17 V, 5 A sync buc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; LCSC C327676

Connections:
/3V3_I2C: J5.2, JP1.2 (B), R8.1, R9.1, R10.1
/5V_PRESENT: R601.2, R602.1, U11.14 (P11)
/6V_CTRL: R700.1, U11.18 (P15)
/6V_EN: D730.1 (K), R700.2, R701.1, U71.1 (EN/UVLO)
/6V_PG: R741.2, R742.1, U11.20 (P17)
/+3V3: C5.1, C7.1, C400.1, C401.1, C402.1, C403.1, C404.1, C405.1, JP1.1 (A), R4.1, R7.1, R12.1, R103.1, R113.1, R123.1, R133.1, R143.1, R153.1, R163.1, R173.1, R183.1, R302.1, R303.1, R312.1, R313.1, R322.1, R323.1, R332.1, R333.1, R342.1, R343.1, R352.1, R353.1, R362.1, R363.1, R372.1, R373.1, R400.1, R401.1, R402.1, R403.1, R404.1, R405.1, R406.1, R407.1, R408.1, R507.1, R508.1, R509.1, R540.1, R541.1, R542.1, R702.1, U10.1 (OUT), U11.24 (VCC), U12.24 (VCC), U13.8 (+Vs), U14.3 (VDD), U15.3 (VDD), U16.3 (VDD), U17.3 (VDD)
/+5V: C600.1, C601.1, C612.1, C622.1, C632.1, D600.1 (K), F4.2, R601.1, R603.1, R604.1, U61.5 (IN), U62.5 (IN), U63.5 (IN)
/+5V_RAW: F4.1, J53.4
/+6V: C725.1, C726.1, C727.1, C733.1, L70.2, R722.1, R731.1, R733.1, U72.5 (IN)
/AON12: C183.1, D180.1 (K), J20.1, J21.1, J22.1, R184.1, R300.1, R310.1, R320.1, R330.1, R340.1, R350.1, R360.1, R370.1, U9.6 (OUT), U30.4 (Vbb), U31.4 (Vbb), U32.4 (Vbb), U33.4 (Vbb), U34.4 (Vbb), U35.4 (Vbb), U36.4 (Vbb), U37.4 (Vbb)
/BST6: C724.1, U73.6 (VBST)
/CSEL5: JP5.2, R150.2
/CSEL6: JP6.2, R160.2
/CSEL7: JP7.2, R170.2
/CTRL0: J3.3, R100.1
/CTRL1: J3.4, R110.1
/CTRL2: J3.5, R120.1
/CTRL3: J3.6, R130.1
/CTRL4: J3.7, R140.1
/CTRL5: J3.8, R150.1
/CTRL6: J3.9, R160.1
/CTRL7: J3.10, R170.1
/DVDT0: C100.1, U1.7 (DVDT)
/DVDT1: C110.1, U2.7 (DVDT)
/DVDT2: C120.1, U3.7 (DVDT)
/DVDT3: C130.1, U4.7 (DVDT)
/DVDT4: C140.1, U5.7 (DVDT)
/DVDT5: C150.1, U6.7 (DVDT)
/DVDT5V5: C610.1, U61.7 (DVDT)
/DVDT5V6: C620.1, U62.7 (DVDT)
/DVDT5V7: C630.1, U63.7 (DVDT)
/DVDT6: C160.1, U7.7 (DVDT)
/DVDT6I: C710.1, U71.7 (DVDT)
/DVDT6O: C730.1, U72.7 (DVDT)
/DVDT7: C170.1, U8.7 (DVDT)
/DVDT8: C180.1, U9.7 (DVDT)
/EN: C506.1, R503.2, R504.1, U50.1 (EN)
/EN0: R100.2, R101.1, U1.1 (EN/UVLO)
/EN1: R110.2, R111.1, U2.1 (EN/UVLO)
/EN2: R120.2, R121.1, U3.1 (EN/UVLO)
/EN3: R130.2, R131.1, U4.1 (EN/UVLO)
/EN4: R140.2, R141.1, U5.1 (EN/UVLO)
/EN5: JP5.1, R151.1, U6.1 (EN/UVLO)
/EN5V5: JP5.3, R611.1, U11.15 (P12), U61.1 (EN/UVLO)
/EN5V6: JP6.3, R621.1, U11.16 (P13), U62.1 (EN/UVLO)
/EN5V7: JP7.3, R631.1, U11.17 (P14), U63.1 (EN/UVLO)
/EN6: JP6.1, R161.1, U7.1 (EN/UVLO)
/EN6O: D730.2 (A), R733.2, R734.1, U72.1 (EN/UVLO)
/EN7: JP7.1, R171.1, U8.1 (EN/UVLO)
/EN_AON: R180.2, R181.1, U9.1 (EN/UVLO)
/EN_BK: R720.2, R721.1, U73.5 (EN)
/EN_SW: J54.2, JP2.2 (B), R503.1
/EXA0: R5.1, U11.21 (A0)
/EXA1: R6.1, U11.2 (A1)
/EXA2: R7.2, U11.3 (A2)
/FANIN0: R300.2, U30.3 (IN)
/FANIN1: R310.2, U31.3 (IN)
/FANIN2: R320.2, U32.3 (IN)
/FANIN3: R330.2, U33.3 (IN)
/FANIN4: R340.2, U34.3 (IN)
/FANIN5: R350.2, U35.3 (IN)
/FANIN6: R360.2, U36.3 (IN)
/FANIN7: R370.2, U37.3 (IN)
/FANPWR0: J30.2, U30.1 (OUT)
/FANPWR1: J31.2, U31.1 (OUT)
/FANPWR2: J32.2, U32.1 (OUT)
/FANPWR3: J33.2, U33.1 (OUT)
/FANPWR4: J34.2, U34.1 (OUT)
/FANPWR5: J35.2, U35.1 (OUT)
/FANPWR6: J36.2, U36.1 (OUT)
/FANPWR7: J37.2, U37.1 (OUT)
/FB6: R722.2, R723.1, U73.4 (VFB)
/FCLK0: R410.1, U14.9 (CLK)
/FCLK1: R411.1, U15.9 (CLK)
/FCLK2: R412.1, U16.9 (CLK)
/FCLK3: R413.1, U17.9 (CLK)
/FPWM0: J30.4, Q30.3 (D), R302.2
/FPWM1: J31.4, Q31.3 (D), R312.2
/FPWM2: J32.4, Q32.3 (D), R322.2
/FPWM3: J33.4, Q33.3 (D), R332.2
/FPWM4: J34.4, Q34.3 (D), R342.2
/FPWM5: J35.4, Q35.3 (D), R352.2
/FPWM6: J36.4, Q36.3 (D), R362.2
/FPWM7: J37.4, Q37.3 (D), R372.2
/FSCL0: R402.2, U12.5 (SC0), U14.2 (SMCLK)
/FSCL1: R404.2, U12.7 (SC1), U15.2 (SMCLK)
/FSCL2: R406.2, U12.9 (SC2), U16.2 (SMCLK)
/FSCL3: R408.2, U12.11 (SC3), U17.2 (SMCLK)
/FSDA0: R401.2, U12.4 (SD0), U14.1 (SMDATA)
/FSDA1: R403.2, U12.6 (SD1), U15.1 (SMDATA)
/FSDA2: R405.2, U12.8 (SD2), U16.1 (SMDATA)
/FSDA3: R407.2, U12.10 (SD3), U17.1 (SMDATA)
/FTACH0: J30.3, R303.2, R304.1
/FTACH1: J31.3, R313.2, R314.1
/FTACH2: J32.3, R323.2, R324.1
/FTACH3: J33.3, R333.2, R334.1
/FTACH4: J34.3, R343.2, R344.1
/FTACH5: J35.3, R353.2, R354.1
/FTACH6: J36.3, R363.2, R364.1
/FTACH7: J37.3, R373.2, R374.1
/G1: D510.2 (A), R513.1, U50.20 (G1)
/G2: D511.2 (A), R523.1, U50.18 (G2)
/G3: D512.2 (A), R533.1, U50.16 (G3)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C100.2, C101.2, C102.2, C103.2, C110.2, C111.2, C112.2, C113.2, C120.2, C121.2, C122.2, C123.2, C130.2, C131.2, C132.2, C133.2, C140.2, C141.2, C142.2, C143.2, C150.2, C151.2, C152.2, C153.2, C160.2, C161.2, C162.2, C163.2, C170.2, C171.2, C172.2, C173.2, C180.2, C181.2, C182.2, C183.2, C400.2, C401.2, C402.2, C403.2, C404.2, C405.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C514.2, C515.2, C516.2, C517.2, C600.2, C601.2, C602.2, C610.2, C611.2, C612.2, C613.2, C620.2, C621.2, C622.2, C623.2, C630.2, C631.2, C632.2, C633.2, C710.2, C711.2, C712.2, C713.2, C720.2, C721.2, C722.2, C723.2, C725.2, C726.2, C727.2, C730.2, C731.2, C732.2, C733.2, C734.2, D1.1 (K), D100.2 (A), D101.1 (K), D110.2 (A), D111.1 (K), D120.2 (A), D121.1 (K), D130.2 (A), D131.1 (K), D140.2 (A), D141.1 (K), D150.2 (A), D151.1 (K), D160.2 (A), D161.1 (K), D170.2 (A), D171.1 (K), D180.2 (A), D181.1 (K), D501.2 (A), D502.2 (A), D503.2 (A), D600.2 (A), D601.1 (K), D610.2 (A), D611.1 (K), D620.2 (A), D621.1 (K), D630.2 (A), D631.1 (K), D740.2 (A), D741.1 (K), J3.1, J4.1, J5.1, J10.2, J11.2, J12.2, J13.2, J14.2, J15.2, J16.2, J17.2, J20.2, J21.2, J22.2, J22.3, J30.1, J31.1, J32.1, J33.1, J34.1, J35.1, J36.1, J37.1, J51.1, J52.4, J52.5, J52.6, J52.7, J52.8, J53.2, J53.3, J54.3, J61.2, J62.2, J63.2, J70.1, J70.2, Q30.2 (S), Q31.2 (S), Q32.2 (S), Q33.2 (S), Q34.2 (S), Q35.2 (S), Q36.2 (S), Q37.2 (S), R3.2, R5.2, R6.2, R101.2, R102.2, R111.2, R112.2, R121.2, R122.2, R131.2, R132.2, R141.2, R142.2, R151.2, R152.2, R161.2, R162.2, R171.2, R172.2, R181.2, R182.2, R301.2, R311.2, R321.2, R331.2, R341.2, R351.2, R361.2, R371.2, R410.2, R411.2, R412.2, R413.2, R501.2, R504.2, R506.2, R512.2, R522.2, R532.2, R602.2, R605.2, R611.2, R612.2, R621.2, R622.2, R631.2, R632.2, R701.2, R710.2, R721.2, R723.2, R730.2, R732.2, R734.2, R742.2, U1.8 (GND), U2.8 (GND), U3.8 (GND), U4.8 (GND), U5.8 (GND), U6.8 (GND), U7.8 (GND), U8.8 (GND), U9.8 (GND), U10.2 (GND), U11.12 (GND), U12.1 (A0), U12.2 (A1), U12.12 (GND), U12.21 (A2), U13.4 (GND), U13.5 (A2), U13.6 (A1), U13.7 (A0), U14.4 (GND), U15.4 (GND), U16.4 (GND), U17.4 (GND), U30.2 (GND), U31.2 (GND), U32.2 (GND), U33.2 (GND), U34.2 (GND), U35.2 (GND), U36.2 (GND), U37.2 (GND), U50.13 (GND), U61.8 (GND), U62.8 (GND), U63.8 (GND), U71.8 (GND), U72.8 (GND), U73.1 (GND)
/GT1: C511.1, D510.1 (K), Q501.4 (G), Q502.4 (G), Q503.4 (G), Q504.4 (G), Q512.4 (G), Q513.4 (G), R513.2
/GT2: C512.1, D511.1 (K), Q505.4 (G), Q506.4 (G), R523.2
/GT3: C513.1, D512.1 (K), Q507.4 (G), Q508.4 (G), R533.2
/HYS: R501.1, U50.3 (HYS)
/ILM0: R102.1, U1.9 (ILM)
/ILM1: R112.1, U2.9 (ILM)
/ILM2: R122.1, U3.9 (ILM)
/ILM3: R132.1, U4.9 (ILM)
/ILM4: R142.1, U5.9 (ILM)
/ILM5: R152.1, U6.9 (ILM)
/ILM5V5: R612.1, U61.9 (ILM)
/ILM5V6: R622.1, U62.9 (ILM)
/ILM5V7: R632.1, U63.9 (ILM)
/ILM6: R162.1, U7.9 (ILM)
/ILM6I: R710.1, U71.9 (ILM)
/ILM6O: R730.1, U72.9 (ILM)
/ILM7: R172.1, U8.9 (ILM)
/ILM8: R182.1, U9.9 (ILM)
/IN1_RAW: F1.1, J50.1
/IN2_RAW: F2.1, J52.1, J52.2, J52.3
/IN3_RAW: F3.1, J53.1
/ITMR0: C101.1, U1.10 (ITIMER)
/ITMR1: C111.1, U2.10 (ITIMER)
/ITMR2: C121.1, U3.10 (ITIMER)
/ITMR3: C131.1, U4.10 (ITIMER)
/ITMR4: C141.1, U5.10 (ITIMER)
/ITMR5: C151.1, U6.10 (ITIMER)
/ITMR5V5: C611.1, U61.10 (ITIMER)
/ITMR5V6: C621.1, U62.10 (ITIMER)
/ITMR5V7: C631.1, U63.10 (ITIMER)
/ITMR6: C161.1, U7.10 (ITIMER)
/ITMR6I: C711.1, U71.10 (ITIMER)
/ITMR6O: C731.1, U72.10 (ITIMER)
/ITMR7: C171.1, U8.10 (ITIMER)
/ITMR8: C181.1, U9.10 (ITIMER)
/LA1: D507.2 (A), R540.2
/LA2: D508.2 (A), R541.2
/LA3: D509.2 (A), R542.2
/LED0: D101.2 (A), R104.2
/LED1: D111.2 (A), R114.2
/LED2: D121.2 (A), R124.2
/LED3: D131.2 (A), R134.2
/LED4: D141.2 (A), R144.2
/LED5: D151.2 (A), R154.2
/LED5V: D601.2 (A), R603.2
/LED5V5: D611.2 (A), R614.2
/LED5V6: D621.2 (A), R624.2
/LED5V7: D631.2 (A), R634.2
/LED6: D161.2 (A), R164.2
/LED6V: D741.2 (A), R740.2
/LED7: D171.2 (A), R174.2
/LED8: D181.2 (A), R184.2
/LEDVB: D1.2 (A), R1.2
/LK2: D508.1 (K), Q509.3 (D)
/LK3: D509.1 (K), Q510.3 (D)
/LK3B: Q510.2 (S), Q511.3 (D)
/MUXRST: R400.2, U12.3 (~RESET)
/OUT0: C103.1, D100.1 (K), J10.1, R104.1, U1.6 (OUT)
/OUT1: C113.1, D110.1 (K), J11.1, R114.1, U2.6 (OUT)
/OUT2: C123.1, D120.1 (K), J12.1, R124.1, U3.6 (OUT)
/OUT3: C133.1, D130.1 (K), J13.1, R134.1, U4.6 (OUT)
/OUT4: C143.1, D140.1 (K), J14.1, R144.1, U5.6 (OUT)
/OUT5: C153.1, D150.1 (K), J15.1, R154.1, U6.6 (OUT)
/OUT5V5: C613.1, D610.1 (K), J61.1, R614.1, U61.6 (OUT)
/OUT5V6: C623.1, D620.1 (K), J62.1, R624.1, U62.6 (OUT)
/OUT5V7: C633.1, D630.1 (K), J63.1, R634.1, U63.6 (OUT)
/OUT6: C163.1, D160.1 (K), J16.1, R164.1, U7.6 (OUT)
/OUT6V: C734.1, D740.1 (K), J70.3, J70.4, R740.1, R741.1, U72.6 (OUT)
/OUT7: C173.1, D170.1 (K), J17.1, R174.1, U8.6 (OUT)
/OV1: R511.2, R512.1, U50.5 (OV1)
/OV2: R521.2, R522.1, U50.7 (OV2)
/OV3: R531.2, R532.1, U50.9 (OV3)
/OVLO: C6.1, R2.2, R3.1, U1.2 (OVLO), U2.2 (OVLO), U3.2 (OVLO), U4.2 (OVLO), U5.2 (OVLO), U6.2 (OVLO), U7.2 (OVLO), U8.2 (OVLO), U9.2 (OVLO), U71.2 (OVLO)
/OVLO5: C602.1, R604.2, R605.1, U61.2 (OVLO), U62.2 (OVLO), U63.2 (OVLO)
/OVLO6: C732.1, R731.2, R732.1, U72.2 (OVLO)
/PRESENT: J3.11, R4.2
/PWMG0: Q30.1 (G), R301.1, U14.5 (PWM1)
/PWMG1: Q31.1 (G), R311.1, U14.7 (PWM2)
/PWMG2: Q32.1 (G), R321.1, U15.5 (PWM1)
/PWMG3: Q33.1 (G), R331.1, U15.7 (PWM2)
/PWMG4: Q34.1 (G), R341.1, U16.5 (PWM1)
/PWMG5: Q35.1 (G), R351.1, U16.7 (PWM2)
/PWMG6: Q36.1 (G), R361.1, U17.5 (PWM1)
/PWMG7: Q37.1 (G), R371.1, U17.7 (PWM2)
/SCL: J5.4, R9.2, U11.22 (SCL), U12.22 (SCL), U13.2 (SCL)
/SDA: J5.3, R8.2, U11.23 (SDA), U12.23 (SDA), U13.1 (SDA)
/SW6: C724.2, L70.1, U73.2 (SW)
/SW_SUP: J54.1, JP2.1 (A), R502.2
/TACH0: R304.2, U14.6 (TACH1)
/TACH1: R314.2, U14.8 (TACH2)
/TACH2: R324.2, U15.6 (TACH1)
/TACH3: R334.2, U15.8 (TACH2)
/TACH4: R344.2, U16.6 (TACH1)
/TACH5: R354.2, U16.8 (TACH2)
/TACH6: R364.2, U17.6 (TACH1)
/TACH7: R374.2, U17.8 (TACH2)
/UV1: R510.2, R511.1, U50.4 (UV1)
/UV2: R520.2, R521.1, U50.6 (UV2)
/UV3: R530.2, R531.1, U50.8 (UV3)
/V1: C501.1, D501.1 (K), D504.2 (A), F1.2, Q501.5 (D), Q502.5 (D), Q512.5 (D), R510.1, U50.24 (V1)
/V2: C502.1, D502.1 (K), D505.2 (A), F2.2, Q505.5 (D), R520.1, U50.23 (V2)
/V3: C503.1, D503.1 (K), D506.2 (A), F3.2, Q507.5 (D), R530.1, U50.22 (V3)
/VBUS: C1.1, C2.1, C3.1, C4.1, C102.1, C112.1, C122.1, C132.1, C142.1, C152.1, C162.1, C172.1, C182.1, C504.1, C505.1, C511.2, C512.2, C513.2, C712.1, Q503.5 (D), Q504.5 (D), Q506.5 (D), Q508.5 (D), Q513.5 (D), R1.1, R2.1, R180.1, R543.1, U1.5 (IN), U2.5 (IN), U3.5 (IN), U4.5 (IN), U5.5 (IN), U6.5 (IN), U7.5 (IN), U8.5 (IN), U9.5 (IN), U10.3 (IN), U71.5 (IN)
/VIN6: C713.1, C720.1, C721.1, C722.1, C723.1, R720.1, U71.6 (OUT), U73.3 (VIN)
/VIN_OR: C507.1, D504.1 (K), D505.1 (K), D506.1 (K), R502.1, R505.1
/VOUT_F: C517.1, R543.2, U50.15 (VOUT)
/VS1: C514.1, Q501.1 (S), Q501.2 (S), Q501.3 (S), Q502.1 (S), Q502.2 (S), Q502.3 (S), Q503.1 (S), Q503.2 (S), Q503.3 (S), Q504.1 (S), Q504.2 (S), Q504.3 (S), Q512.1 (S), Q512.2 (S), Q512.3 (S), Q513.1 (S), Q513.2 (S), Q513.3 (S), U50.21 (VS1)
/VS2: C515.1, Q505.1 (S), Q505.2 (S), Q505.3 (S), Q506.1 (S), Q506.2 (S), Q506.3 (S), U50.19 (VS2)
/VS3: C516.1, Q507.1 (S), Q507.2 (S), Q507.3 (S), Q508.1 (S), Q508.2 (S), Q508.3 (S), U50.17 (VS3)
/~FLT0: J4.2, R103.2, U1.4 (~FLT), U11.4 (P00)
/~FLT1: J4.3, R113.2, U2.4 (~FLT), U11.5 (P01)
/~FLT2: J4.4, R123.2, U3.4 (~FLT), U11.6 (P02)
/~FLT3: J4.5, R133.2, U4.4 (~FLT), U11.7 (P03)
/~FLT4: J4.6, R143.2, U5.4 (~FLT), U11.8 (P04)
/~FLT5: J4.7, R153.2, U6.4 (~FLT), U11.9 (P05), U61.4 (~FLT)
/~FLT6V: R702.2, U11.19 (P16), U71.4 (~FLT), U72.4 (~FLT)
/~FLT6: J4.8, R163.2, U7.4 (~FLT), U11.10 (P06), U62.4 (~FLT)
/~FLT7: J4.9, R173.2, U8.4 (~FLT), U11.11 (P07), U63.4 (~FLT)
/~FLT_AON: J4.10, R183.2, U9.4 (~FLT), U11.13 (P10)
/~I2C_INT: J5.5, R10.2, R12.2, U11.1 (~INT), U13.3 (O.S.), U14.10 (~ALERT), U15.10 (~ALERT), U16.10 (~ALERT), U17.10 (~ALERT)
/~SHDN: R505.2, R506.1, U50.2 (~SHDN)
/~VALID1: D507.1 (K), Q509.1 (G), Q510.1 (G), R507.2, U50.10 (~VALID1)
/~VALID2: Q509.2 (S), Q511.1 (G), R508.2, U50.11 (~VALID2)
/~VALID3: Q511.2 (S), R509.2, U50.12 (~VALID3)

Notes on the sheet:
U1: DUT0 switched 12 V, 5 A
U2: DUT1 switched 12 V, 5 A
U3: DUT2 switched 12 V, 5 A
U4: DUT3 switched 12 V, 5 A
U5: DUT4 switched 12 V, 5 A
U6: DUT5 switched 12 V, 5 A (or 5 V via JP5)
U7: DUT6 switched 12 V, 5 A (or 5 V via JP6)
U8: DUT7 switched 12 V, 5 A (or 5 V via JP7)
U9: Always-on 12 V, 5 A shared
Always-on loads (Mimas x2, GS105, fans)
8 x 4-pin PWM fans: see the fan section below (FAN0-1 KVM front panel, FAN2-4 shelf plate A, FAN5-7 shelf plate B; issue 0052).
FAN0 (KVM front panel): switch + PWM inverter + tach
FAN1 (KVM front panel): switch + PWM inverter + tach
FAN2 (shelf plate A): switch + PWM inverter + tach
FAN3 (shelf plate A): switch + PWM inverter + tach
FAN4 (shelf plate A): switch + PWM inverter + tach
FAN5 (shelf plate B): switch + PWM inverter + tach
FAN6 (shelf plate B): switch + PWM inverter + tach
FAN7 (shelf plate B): switch + PWM inverter + tach
I2C housekeeping (shield bus via J5): TCA9548A 0x70 -> 4 x EMC2302-1 (0x2E), TMP75 0x48
Bring-up (host or FPGA), per controller m = 0..3: write 0x70 <- (1 << m) select mux channel m 0x2E reg 2Bh <- 03h PWM1/2 push-pull 0x2E reg 2Ah <- 03h PWM1/2 inverted (2N7002 inverts again) 0x2E reg 30h / 40h <- duty fan 2m / 2m+1, 00h-FFh = 0-100 % 0x2E reg 20h <- 60h keep the 4 s watchdog armed (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
VBUS (from the input stage), 3.3 V, bulk
VBUS 12 V nominal, 25 A max (input fuse). Sum of DUT limits (8 x 5 A + 5 A) exceeds the input: the input fuse/PSU is the total limit.
Control from shield (1x11, pin 2 = key), fault/status
TCA9535 status/control expander on the shield I2C bus, addr 0x24 (fitted)
Notes * eFuse = TPS259470A (auto-retry, owner 2026-11-27; the L latch-off part is unstocked). All 14 eFuses (DUT, 5 V, 6 V outlet, always-on) the same part. EN/UVLO threshold 1.2 V: 3.3 V logic drives it directly. * 20k pull-downs: everything off when the shield is unplugged, unpowered or in reset.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
Input V1: Banana 4 mm, fuse 25A ATO, priority 1
Q501/Q502/Q512: input side (D=V1) Q503/Q504/Q513: output side (D=VBUS) - two in parallel each side for 25 A, Q512/Q513 DNP
Input V2: PCIe 8-pin, fuse 15A ATO, priority 2
Q505: input side (D=V2) Q506: output side (D=VBUS)
Input V3: Molex 4-pin, fuse 10A ATO, priority 3
Q507: input side (D=V3) Q508: output side (D=VBUS)
U50 LTC4417: prioritised PowerPath, V1 > V2 > V3
Master on/off: front-panel illuminated rocker (SPST, 12 V lamp between LOAD and GND), wired to J54. Cable unplugged or switch off -> EN low -> VBUS off -> every output off, including the always-on Mimas/switch/fan group. JP2 bridges the switch for bench use.
Input-selected LEDs (front edge), 3.3 V from the board LDO
~VALIDn are open drain (low = input n valid). LED2 = V2 & !V1, LED3 = V3 & !V1 & !V2. LEDs are dark when VBUS is off (master switch off).
+5 V input: Molex J53 pin 4 -> F4 10 A -> TVS -> +5V (not via the LTC4417; issue 0055)
J53 pin 4 (+5V_RAW) is placed in the input stage (Input V3: Molex 4-pin).
Banana/PCIe-only operation: no 5 V, the 5 V eFuses are unpowered (FLT open = no fault), D601 is dark and 5V_PRESENT reads low (U11 P1.1, if fitted). Master switch off: the shield is unpowered, CTRL5-7 are pulled low, every output is off.
U61: DUT5 5 V ONLY, 3 A (shares CTRL5 with the 12 V output)
